<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\2026_C_AV_PRC_IOC.ewp</path>
  </project>
  <batchBuild />
</workspace>
